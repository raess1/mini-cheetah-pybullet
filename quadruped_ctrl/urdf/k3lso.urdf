Commit message: change inertia body

File: quadruped_ctrl/urdf/k3lso.urdf (robot description, URDF)
Before this commit: robot k3lso, 17 links, 16 joints
Links:
- link body: mass 5.7 -> 4.75
